# Keil uVision project pro.uvprojx, settings and files
target pro (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: pro +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output="E:\PanelPro-main\py\pro.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,APP_BASE=0x800C000
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/LCD;../BSP/AT24CXX;../BSP/IIC;../BSP/TOUCH;../BSP/GUI;../BSP/KEY;../BSP/SPI;../BSP/RGB;../SYSTEM;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/LVGL;../Middlewares/LVGL/examples/porting;../Middlewares/LVGL/src;../Middlewares/LVGL/src/core;../Middlewares/LVGL/src/draw;../Middlewares/LVGL/src/draw/sw;../Middlewares/LVGL/src/extra;../Middlewares/LVGL/demos;../Middlewares/LVGL/demos/stress;../User/Tasks/Inc;../User/Tasks/Src;../User/Func/Inc;../User/Func/Src;../User/GUI;../User/GUI/screens/Inc;../User/GUI/screens/Src;../User/GUI/fonts;../User/GUI/image;../BSP/TOUCH_SENSOR;../SEGGER_RTT_V688c/RTT;..\..\F407_IAR\Bootloader\Inc;..\..\F407_IAR\Bootloader\Src
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x74000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/System
    ../SYSTEM/: delay.c
  group Application/User/Tasks
    ../User/Tasks/Src/: user_testTask.c user_HardwareInitTask.c user_LVGLTask.c user_TaskInit.c user_KeyTask.c user_ScrRenewTask.c user_MotorTask.c user_LightTask.c user_RTCShowTask.c test_printf.c
  group Application/User/GUI
    ../User/GUI/screens/Src/: ui_HomePage.c ui_MeunPage.c ui_AboutPage.c ui_CalendarPage.c ui_LightPage.c ui_MotorPage.c
    ../User/GUI/: ui.c ui_helpers.c ui_events.h
  group Application/User/GUI_FONT
    ../User/GUI/fonts/: ui_font_iconfont10.c ui_font_iconfont20.c ui_font_iconfont31.c ui_font_iconfont40.c ui_font_zhongyaun16.c ui_font_zhongyaun20.c ui_font_zhongyuan.c ui_font_zhongyuan30.c ui_font_zhongyuan40.c ui_font_zhongyuan18.c ui_font_zhongyuan48.c
  group Application/User/GUI_IMAGE
    ../User/GUI/image/: ui_img_1118704736.c
  group Application/User/MidFunc
    ../User/Func/Src/: PageManager.c
  group Application/User/RTT
    ../SEGGER_RTT_V688c/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP
    ../BSP/LCD/: lcd.c
    ../BSP/AT24CXX/: 24cxx.c
    ../BSP/IIC/: myiic.c
    ../BSP/TOUCH/: touch.c
    ../BSP/GUI/: gui.c
    ../BSP/KEY/: key.c
    ../BSP/RGB/: RGB_Led.c
    ../BSP/TOUCH_SENSOR/: Touch_ Sensor.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LVGL/Port
    ../Middlewares/LVGL/examples/porting/: lv_port_disp_template.c lv_port_indev_template.c
  group Middlewares/LVGL/Core
    ../Middlewares/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/LVGL/: lv_conf.h lvgl.h
  group Middlewares/LVGL/Draw
    ../Middlewares/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c lv_draw_layer.c lv_draw_transform.c
    ../Middlewares/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_layer.c lv_draw_sw_transform.c
  group Middlewares/LVGL/Extra
    ../Middlewares/LVGL/src/extra/: lv_extra.c
    ../Middlewares/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/src/extra/widgets/led/: lv_led.c
    ../Middlewares/LVGL/src/extra/widgets/list/: lv_list.c
    ../Middlewares/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/src/extra/widgets/span/: lv_span.c
    ../Middlewares/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/src/extra/widgets/win/: lv_win.c
  group Middlewares/LVGL/Font
    ../Middlewares/LVGL/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c
  group Middlewares/LVGL/Hal
    ../Middlewares/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/Misc
    ../Middlewares/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/Widgets
    ../Middlewares/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/LVGL/demo
    ../Middlewares/LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../Middlewares/LVGL/demos/benchmark/: lv_demo_benchmark.c
    ../Middlewares/LVGL/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../Middlewares/LVGL/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Middlewares/LVGL/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../Middlewares/LVGL/demos/stress/: lv_demo_stress.c
    ../Middlewares/LVGL/demos/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ../Middlewares/LVGL/demos/widgets/: lv_demo_widgets.c
    ../Middlewares/LVGL/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
  group OTA
    ../../F407_IAR/Bootloader/Src/: flash_ops.c metadata.c
software components: CMSIS:CORE 4.3.0
